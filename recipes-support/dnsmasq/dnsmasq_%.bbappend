
SYSTEMD_AUTO_ENABLE:pn-dnsmasq = "disable"
